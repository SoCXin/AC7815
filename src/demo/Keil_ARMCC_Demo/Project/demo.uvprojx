# Keil uVision project demo.uvprojx, settings and files
target Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AC7811OBGE AutoChips
  pack: AutoChips.AC781x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Drivers\DMA;..\Drivers\eFlash;..\Drivers\GPIO;..\Drivers\TIMER;..\Drivers\UART;..\Drivers\WDG;..\Drivers\IIC;..\Drivers\SPI
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Device
    ../Device/Source/: ac78xx_ckgen.c ac78xx_debugout.c ac78xx_spm.c system_ac78xx.c
    ../Device/Source/ARM/: startup_ac78xx.s
  group Drivers
    ../Drivers/DMA/: ac78xx_dma.c
    ../Drivers/eFlash/: ac78xx_eflash.c
    ../Drivers/GPIO/: ac78xx_gpio.c
    ../Drivers/TIMER/: ac78xx_timer.c
    ../Drivers/UART/: ac78xx_uart.c
    ../Drivers/WDG/: ac78xx_wdg.c
    ../Drivers/SPI/: ac78xx_spi.c
    ../Drivers/IIC/: ac78xx_i2c.c
  group App
    ../App/: main.c
software components: CMSIS:CORE 5.0.1

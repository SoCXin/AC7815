# Keil uVision project demo.uvprojx, settings and files
target Demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AC7811OBGE AutoChips
  pack: AutoChips.AC781x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: .\Objects\hex2bin.exe .\Objects\demo.hex
  group Device
    ../Device/Source/: ac78xx_ckgen.c ac78xx_debugout.c ac78xx_spm.c system_ac78xx.c syscalls.c
    ../Device/Source/ARM/: startup_ac78xx.S
  group Drivers
    ../Drivers/DMA/: ac78xx_dma.c
    ../Drivers/GPIO/: ac78xx_gpio.c
    ../Drivers/TIMER/: ac78xx_timer.c
    ../Drivers/UART/: ac78xx_uart.c
    ../Drivers/WDG/: ac78xx_wdg.c
  group App
    ../App/: main.c
software components: CMSIS:CORE 5.0.1
